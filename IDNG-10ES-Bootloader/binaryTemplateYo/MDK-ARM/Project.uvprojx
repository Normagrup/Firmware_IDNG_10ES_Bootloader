# Keil uVision project Project.uvprojx, settings and files
target STM320518_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F051C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM320518_EVAL +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,USE_STM320518_EVAL,STM320518_EVAL_REVB
  c include: .\..\;.\..\inc;.\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\..\..\..\..\Utilities\STM32_EVAL;.\..\..\..\..\Utilities\STM32_EVAL\Common;.\..\..\..\..\Utilities\STM32_EVAL\STM320518_EVAL;..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\Utilities\STM32_EVAL\STM320518_EVAL;..\..\Utilities\STM32_EVAL\Common;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Source\Templates\arm
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x200000c0 size 0x1f40
  group CMSIS
    ../src/: system_stm32f0xx.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group STM320518_EVAL
    ../../Utilities/STM32_EVAL/STM320518_EVAL/: stm320518_eval.c stm320518_eval.h
  group User
    ../src/: main.c stm32f0xx_it.c
software components: CMSIS:CORE 4.3.0
